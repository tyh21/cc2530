# IAR project project.ewp, settings and files
configuration Debug (8051, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl8051Normal.h
  General.OGChipSelectMenu: 8052 Generic 8052
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: src\basicrf
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\_generic\lnk51ew_8052.xcl
configuration Release (8051)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  A8051.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group app
    src/: epd2in13.c epd2in13.h epd_paint.c epd_paint.h clockfont.c clockfont.h clockface.c clockface.h main.c
  group basicrf
    src/basicrf/: basic_rf.c basic_rf.h clock.c clock.h hal_assert.c hal_assert.h hal_defs.h hal_int.c hal_int.h hal_mcu.c hal_mcu.h hal_rf.c hal_rf.h hal_types.h util.c util.h
  group piclink
    src/: pl_node.c pl_node.h pl_proto.c pl_proto.h
