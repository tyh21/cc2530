# IAR project project.ewp, settings and files
configuration Debug (8051, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl8051Normal.h
  General.OGChipSelectMenu: 8052 Generic 8052
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: src\basicrf
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\_generic\lnk51ew_8052.xcl
configuration Release (8051)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  A8051.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group app
    src/: font8.c font16.c font24.c fonts.h epd2in9.c epd2in9.h main.c
  group piclink
    src/: pl_proto.c pl_proto.h uart0.c uart0.h pl_gateway.c pl_gateway.h
  group basicrf
    src/basicrf/: basic_rf.c basic_rf.h hal_rf.c hal_rf.h hal_mcu.c hal_mcu.h clock.c clock.h hal_int.c hal_int.h hal_assert.c hal_assert.h util.c util.h hal_defs.h hal_types.h
